File: v1/kicad/Unused.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U13 CD40106B, U6 CD4520

Commit message: Adding KiKit multiboarding
Connections:
- net GND renamed GNDD
